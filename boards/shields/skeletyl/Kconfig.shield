## boards/shields/skeletyl/Kconfig.shield
```kconfig
config SHIELD_SKELETYL_DONGLE
    def_bool $(shields_list_contains,skeletyl_dongle)
```
